## config/boards/shields/kgrid40/Kconfig.shield
```kconfig
config SHIELD_KGRID40
    def_bool $(shields_list_contains,kgrid40)
    select ZMK_KEYBOARD_NAME
```
